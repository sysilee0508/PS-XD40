# IAR project PS-XD40.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\App\Main; ..\App\MCU; ..\App\Drivers; ..\App\Etc; ..\App\Graphic; ..\App\Video; ..\App; ..\App\Splitter\VS4210Inc; ..\App\Decoder
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PS-XD40.hex
  ILINK.IlinkOutputFile: PS-XD40.out
  ILINK.IlinkIcfFile: ..\Project\stm32f103xC.icf
  ILINK.IlinkAdditionalLibs: ..\App\Splitter\VS4210Lib\libVS4210.a; ..\App\Splitter\VS4210Lib\libhdmirx.a; ..\App\Splitter\VS4210Lib\libite66121.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  group APP/Decoder
    ../App/Decoder/: coax_table.h NVP6158.c NVP6158.h raptor3_api.c raptor3_drv.c video_eq_table.h video_fmt_input.h video_fmt_output.h video_input_table.h
  group APP/Drivers
    ../App/Drivers/: mdin3xx.c mdin3xx.h mdinaero.h mdinaux.c mdinbus.c mdinbus.h mdincoef.c mdincur.c mdincur.h mdindly.c mdindly.h mdinfont.h mdinfrmt.c mdingac.c mdingac.h mdinhtx.c mdini2c.c mdini2c.h mdinipc.c mdinosd.c mdinosd.h mdinpalt.h mdintrue.h mdintype.h
  group APP/Etc
    ../App/Etc/: delay.c delay.h
  group APP/Graphic
    ../App/Graphic/: item.c item.h menu.c menu.h osd.c osd.h osdmenu.h
  group APP/Main
    ../App/Main/: alarm_remotekey.c alarm_remotekey.h common.h display_mode.c key.c key.h main.c main.h osd_display.c osd_display.h Rtc.c Rtc.h sequence.c sequence.h
  group APP/MCU
    ../App/MCU/: i2c.c i2c.h MCU.c MCU.h stm32f10x_conf.h timer.c timer.h
  group APP/Splitter
    ../App/Splitter/: VS4210.c VS4210.h
  group APP/Video
    ../App/Video/: demo.c mfccoef.h video.c video.h
  group LIB/CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group LIB/STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c
