<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PS-XD40_MDIN.ewp</path>
  </project>
  <batchBuild/>
</workspace>


