<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PS-40XD_MDIN2CH.ewp</path>
    </project>
    <batchBuild />
</workspace>
